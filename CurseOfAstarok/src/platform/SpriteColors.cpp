#include "ArduboyCompat.h"
#include "../utils/Constants.h"
#include "../images/Images.h"
struct Entry { const uint8_t *image; uint8_t color; bool mask; bool player; uint8_t artId; };
static const Entry entries[] = {
 {Images::Rune_Symbols, RUNE_SYMBOL_0, false, false, 65},
 {Images::ItemShop_Potions, POTION_FIRE, false, false, 128},
 {Images::Sky, ART_SKY, false, false, 0},
 {Images::Cloud_01, ART_CLOUD_01, false, false, 1},
 {Images::Cloud_02, ART_CLOUD_02, false, false, 2},
 {Images::Crates, ART_CRATES, false, false, 3},
 {Images::Crates_Mask, COLOR_INK, true, false, 255},
 {Images::Grass, ART_GRASS, false, false, 4},
 {Images::Grass_mask, COLOR_INK, true, false, 255},
 {Images::Town_Gound, ART_TOWN_GOUND, false, false, 5},
 {Images::Arrow_Up_Dialogue, ART_ARROW_UP_DIALOGUE, false, false, 6},
 {Images::Arrow_Down_Dialogue, ART_ARROW_DOWN_DIALOGUE, false, false, 7},
 {Images::Arrow_Up, ART_ARROW_UP, false, false, 8},
 {Images::Arrow_Up_Small, ART_ARROW_UP_SMALL, false, false, 9},
 {Images::Arrow_Down, ART_ARROW_DOWN, false, false, 10},
 {Images::Arrow_Down_Small, ART_ARROW_DOWN_SMALL, false, false, 11},
 {Images::Arrow_Left, ART_ARROW_LEFT, false, false, 12},
 {Images::Arrow_Right, ART_ARROW_RIGHT, false, false, 13},
 {Images::HandPointer, ART_HAND_POINTER, false, false, 14},
 {Images::Town_Sign, ART_TOWN_SIGN, false, false, 15},
 {Images::Tombstone, ART_TOMBSTONE, false, false, 16},
 {Images::Tombstone2, ART_TOMBSTONE2, false, false, 17},
 {Images::Pumpkin, ART_PUMPKIN, false, false, 18},
 {Images::Pumpkin_Mask, COLOR_INK, true, false, 255},
 {Images::SavingPost, ART_SAVING_POST, false, false, 19},
 {Images::HP, ART_HP, false, false, 20},
 {Images::MrBlinky, ART_MR_BLINKY, false, false, 21},
 {Images::MrBlinky_Mask, COLOR_INK, true, false, 255},
 {Images::Tree, ART_TREE, false, false, 22},
 {Images::TitleScreen, ART_TITLE_SCREEN, false, false, 23},
 {Images::TitleScreen_PressA, ART_TITLE_SCREEN_PRESS_A, false, false, 24},
 {Images::Enemy_InfoPanel, ART_ENEMY_INFO_PANEL, false, false, 25},
 {Images::Enemy_InfoPanel_Mask, COLOR_INK, true, false, 255},
 {Images::GelatinousCube_00, ART_GELATINOUS_CUBE_00, false, false, 26},
 {Images::GelatinousCube_01, ART_GELATINOUS_CUBE_01, false, false, 27},
 {Images::GelatinousCube_02, ART_GELATINOUS_CUBE_02, false, false, 28},
 {Images::GelatinousCube_03, ART_GELATINOUS_CUBE_03, false, false, 29},
 {Images::SmallWerewolf_00, ART_SMALL_WEREWOLF_00, false, false, 30},
 {Images::SmallWerewolf_01, ART_SMALL_WEREWOLF_01, false, false, 31},
 {Images::SmallWerewolf_02, ART_SMALL_WEREWOLF_02, false, false, 32},
 {Images::LargeWerewolf_Head, ART_LARGE_WEREWOLF_HEAD, false, false, 33},
 {Images::LargeWerewolf_Head_Mask, COLOR_INK, true, false, 255},
 {Images::LargeWerewolf_Torso, ART_LARGE_WEREWOLF_TORSO, false, false, 34},
 {Images::LargeWerewolf_Bottom, ART_LARGE_WEREWOLF_BOTTOM, false, false, 35},
 {Images::AztaroK_Left, ART_AZTARO_K_LEFT, false, false, 36},
 {Images::AztaroK_Left_Mask, COLOR_INK, true, false, 255},
 {Images::AztaroK_Middle, ART_AZTARO_K_MIDDLE, false, false, 37},
 {Images::AztaroK_Right, ART_AZTARO_K_RIGHT, false, false, 38},
 {Images::AztaroK_Right_Mask, COLOR_INK, true, false, 255},
 {Images::AztaroK_Dead, ART_AZTARO_K_DEAD, false, false, 39},
 {Images::Skeleton_00, ART_SKELETON_00, false, false, 40},
 {Images::Skeleton_01, ART_SKELETON_01, false, false, 41},
 {Images::Skeleton_02, ART_SKELETON_02, false, false, 42},
 {Images::DMGFire, ART_DMGFIRE, false, false, 43},
 {Images::DMGMist, ART_DMGMIST, false, false, 44},
 {Images::hpGauge, ART_HP_GAUGE, false, false, 45},
 {Images::hpGauge_Mask, COLOR_INK, true, false, 255},
 {Images::Gauge, ART_GAUGE, false, false, 46},
 {Images::spGauge, ART_SP_GAUGE, false, false, 47},
 {Images::spGauge_Mask, COLOR_INK, true, false, 255},
 {Images::gpGauge, ART_GP_GAUGE, false, false, 48},
 {Images::gpGauge_Mask, COLOR_INK, true, false, 255},
 {Images::Numbers_4x4, ART_NUMBERS_4X4, false, false, 49},
 {Images::Inventory_TL, ART_INVENTORY_TL, false, false, 50},
 {Images::Inventory_TR, ART_INVENTORY_TR, false, false, 51},
 {Images::Inventory_BL, ART_INVENTORY_BL, false, false, 52},
 {Images::Inventory_BR, ART_INVENTORY_BR, false, false, 53},
 {Images::Castle_LH_Top, ART_CASTLE_LH_TOP, false, false, 54},
 {Images::Castle_LH_Top_Mask, COLOR_INK, true, false, 255},
 {Images::Castle_RH_Top, ART_CASTLE_RH_TOP, false, false, 55},
 {Images::Castle_LH_Mid, ART_CASTLE_LH_MID, false, false, 56},
 {Images::Castle_LH_Bottom, ART_CASTLE_LH_BOTTOM, false, false, 57},
 {Images::Castle_RH_Bottom, ART_CASTLE_RH_BOTTOM, false, false, 58},
 {Images::Castle_RH_Bottom_Mask, COLOR_INK, true, false, 255},
 {Images::Castle_Floor, ART_CASTLE_FLOOR, false, false, 59},
 {Images::Castle_Stairs, ART_CASTLE_STAIRS, false, false, 60},
 {Images::Castle_DarkBrick, ART_CASTLE_DARK_BRICK, false, false, 61},
 {Images::Chain, ART_CHAIN, false, false, 62},
 {Images::Chest, ART_CHEST, false, false, 63},
 {Images::Skull, ART_SKULL, false, false, 64},
 {Images::Rune_Frame_00, ART_RUNE_FRAME_00, false, false, 66},
 {Images::Rune_Frame_01, ART_RUNE_FRAME_01, false, false, 67},
 {Images::Rune_Frame_02, ART_RUNE_FRAME_02, false, false, 68},
 {Images::Rune_Frame_03, ART_RUNE_FRAME_03, false, false, 69},
 {Images::Rune_Frame_04, ART_RUNE_FRAME_04, false, false, 70},
 {Images::Rune_Frame_05, ART_RUNE_FRAME_05, false, false, 71},
 {Images::Rune_Frame_06, ART_RUNE_FRAME_06, false, false, 72},
 {Images::Rune_Frame_07, ART_RUNE_FRAME_07, false, false, 73},
 {Images::Rune_Frame_08, ART_RUNE_FRAME_08, false, false, 74},
 {Images::Rune_Frame_09, ART_RUNE_FRAME_09, false, false, 75},
 {Images::Rune_Frame_10, ART_RUNE_FRAME_10, false, false, 76},
 {Images::Rune_Frame_11, ART_RUNE_FRAME_11, false, false, 77},
 {Images::Rune_Frame_12, ART_RUNE_FRAME_12, false, false, 78},
 {Images::Rune_Frame_13, ART_RUNE_FRAME_13, false, false, 79},
 {Images::Rune_Frame_14, ART_RUNE_FRAME_14, false, false, 80},
 {Images::Rune_Frame_15, ART_RUNE_FRAME_15, false, false, 81},
 {Images::Rune_Frame_16, ART_RUNE_FRAME_16, false, false, 82},
 {Images::Rune_Frame_Mask, COLOR_INK, true, false, 255},
 {Images::Coins, ART_COINS, false, false, 83},
 {Images::SPGraphic, ART_SPGRAPHIC, false, false, 84},
 {Images::PPOT, ART_PPOT, false, false, 85},
 {Images::Sounds, ART_SOUNDS, false, false, 86},
 {Images::Helmet_00, ART_HELMET_00, false, false, 87},
 {Images::Helmet_01, ART_HELMET_01, false, false, 88},
 {Images::Helmet_02, ART_HELMET_02, false, false, 89},
 {Images::Helmet_00_Mask, COLOR_INK, true, false, 255},
 {Images::Helmet_01_Mask, COLOR_INK, true, false, 255},
 {Images::Helmet_02_Mask, COLOR_INK, true, false, 255},
 {Images::Player_Idle_00, ART_PLAYER_IDLE_00, false, true, 90},
 {Images::Player_Idle_01, ART_PLAYER_IDLE_01, false, true, 91},
 {Images::Player_Idle_02, ART_PLAYER_IDLE_02, false, true, 92},
 {Images::Player_Walking_00, ART_PLAYER_WALKING_00, false, true, 93},
 {Images::Player_Walking_01, ART_PLAYER_WALKING_01, false, true, 94},
 {Images::Player_Walking_02, ART_PLAYER_WALKING_02, false, true, 95},
 {Images::Player_Walking_03, ART_PLAYER_WALKING_03, false, true, 96},
 {Images::Player_Idle_00_Mask, COLOR_INK, true, false, 255},
 {Images::Player_Idle_01_Mask, COLOR_INK, true, false, 255},
 {Images::Player_Idle_02_Mask, COLOR_INK, true, false, 255},
 {Images::Player_Walking_00_Mask, COLOR_INK, true, false, 255},
 {Images::Player_Walking_01_Mask, COLOR_INK, true, false, 255},
 {Images::Player_Walking_02_Mask, COLOR_INK, true, false, 255},
 {Images::Player_Walking_03_Mask, COLOR_INK, true, false, 255},
 {Images::Jump_Effect, ART_JUMP_EFFECT, false, false, 97},
 {Images::RollsLeft, ART_ROLLS_LEFT, false, false, 98},
 {Images::NPC, ART_NPC, false, false, 99},
 {Images::NPC_EOG, ART_NPC_EOG, false, false, 100},
 {Images::Recast, ART_RECAST, false, true, 101},
 {Images::Recast_Mask, COLOR_INK, true, false, 255},
 {Images::ItemsBuilding_Top, ART_ITEMS_BUILDING_TOP, false, false, 102},
 {Images::ItemsBuilding_Top_Mask, COLOR_INK, true, false, 255},
 {Images::ItemsBuilding_Bottom, ART_ITEMS_BUILDING_BOTTOM, false, false, 103},
 {Images::RunesBuilding_Top, ART_RUNES_BUILDING_TOP, false, false, 104},
 {Images::RunesBuilding_Top_Mask, COLOR_INK, true, false, 255},
 {Images::RunesBuilding_Bottom, ART_RUNES_BUILDING_BOTTOM, false, false, 105},
 {Images::RunesBuilding_Side, ART_RUNES_BUILDING_SIDE, false, false, 106},
 {Images::ShopKeeper_Item, ART_SHOP_KEEPER_ITEM, false, false, 107},
 {Images::ShopKeeper_Common, ART_SHOP_KEEPER_COMMON, false, false, 108},
 {Images::ShopKeeper_Rune, ART_SHOP_KEEPER_RUNE, false, false, 109},
 {Images::ShopKeeper_Panel, ART_SHOP_KEEPER_PANEL, false, false, 110},
 {Images::ItemShop_Effect_00, ART_ITEM_SHOP_EFFECT_00, false, false, 111},
 {Images::ItemShop_Effect_01, ART_ITEM_SHOP_EFFECT_01, false, false, 112},
 {Images::ItemShop_Effect_02, ART_ITEM_SHOP_EFFECT_02, false, false, 113},
 {Images::ItemShop_Effect_03, ART_ITEM_SHOP_EFFECT_03, false, false, 114},
 {Images::ItemShop_Effect_04, ART_ITEM_SHOP_EFFECT_04, false, false, 115},
 {Images::ItemShop_Effect_05, ART_ITEM_SHOP_EFFECT_05, false, false, 116},
 {Images::ItemShop_Names_00, ART_ITEM_SHOP_NAMES_00, false, false, 117},
 {Images::ItemShop_Names_01, ART_ITEM_SHOP_NAMES_01, false, false, 118},
 {Images::ItemShop_Names_02, ART_ITEM_SHOP_NAMES_02, false, false, 119},
 {Images::ItemShop_Names_03, ART_ITEM_SHOP_NAMES_03, false, false, 120},
 {Images::ItemShop_Names_04, ART_ITEM_SHOP_NAMES_04, false, false, 121},
 {Images::ItemShop_Names_05, ART_ITEM_SHOP_NAMES_05, false, false, 122},
 {Images::ItemShop_HelmetBase, ART_ITEM_SHOP_HELMET_BASE, false, false, 123},
 {Images::ItemShop_PotionBase, ART_ITEM_SHOP_POTION_BASE, false, false, 124},
 {Images::ItemShop_Potion_Mask, COLOR_INK, true, false, 255},
 {Images::ItemShop_Helmet_Mask, COLOR_INK, true, false, 255},
 {Images::ItemShop_Helmet_00, ART_ITEM_SHOP_HELMET_00, false, false, 125},
 {Images::ItemShop_Helmet_01, ART_ITEM_SHOP_HELMET_01, false, false, 126},
 {Images::ItemShop_Helmet_02, ART_ITEM_SHOP_HELMET_02, false, false, 127},
 {Images::RuneShop_Effect_00, ART_RUNE_SHOP_EFFECT_00, false, false, 129},
 {Images::RuneShop_Effect_01, ART_RUNE_SHOP_EFFECT_01, false, false, 130},
 {Images::RuneShop_Effect_02, ART_RUNE_SHOP_EFFECT_02, false, false, 131},
 {Images::RuneShop_Effect_03, ART_RUNE_SHOP_EFFECT_03, false, false, 132},
 {Images::RuneShop_Names_00, ART_RUNE_SHOP_NAMES_00, false, false, 133},
 {Images::RuneShop_Names_01, ART_RUNE_SHOP_NAMES_01, false, false, 134},
 {Images::RuneShop_Names_02, ART_RUNE_SHOP_NAMES_02, false, false, 135},
 {Images::RuneShop_Names_03, ART_RUNE_SHOP_NAMES_03, false, false, 136},
 {Images::RuneShop_Frame, ART_RUNE_SHOP_FRAME, false, false, 137},
 {Images::ClosedDoor, ART_CLOSED_DOOR, false, false, 138},
 {Images::Shop_Numbers, ART_SHOP_NUMBERS, false, false, 139},
 {Images::UOM_GP, ART_UOM_GP, false, false, 140},
 {Images::UOM_SP, ART_UOM_SP, false, false, 141},
 {Images::Inventory_Marker, ART_INVENTORY_MARKER, false, false, 142},
 {Images::Inventory_Helmet_Marker, ART_INVENTORY_HELMET_MARKER, false, false, 143},
 {Images::LeaveShop, ART_LEAVE_SHOP, false, false, 144},
 {Images::LeaveShop_Image, ART_LEAVE_SHOP_IMAGE, false, false, 145},
 {Images::Bye, ART_BYE, false, false, 146},
 {Images::Bye_Mask, COLOR_INK, true, false, 255},
};
// Repeated terrain tiles and animation frames reuse the same small cache.
// A miss still resolves against the one editable color catalog above.
static const Entry *findStyle(const uint8_t *image) {
 struct Slot { const uint8_t *key; const Entry *entry; };
 static Slot cache[16];
 Slot &slot=cache[(reinterpret_cast<uintptr_t>(image)>>3)&15];
 if(slot.key==image)return slot.entry;
 slot.key=image;slot.entry=nullptr;
 for(const auto &e:entries)if(e.image==image){slot.entry=&e;break;}
 return slot.entry;
}
uint8_t spriteColor(const uint8_t *image,uint8_t frame,uint8_t fallback,uint8_t baseOverride) {
 if(videoOptions.monochrome) {
   // This village sprite was normalized from inverted white-background art.
   if(image==Images::Tombstone)return COLOR_INK;
   const Entry *e=findStyle(image);return e && e->mask ? COLOR_INK : (e ? COLOR_TEXT : fallback);
 }

 const Entry *e=findStyle(image);
 if(e && e->player && videoOptions.playerColor)return videoOptions.playerColor;
 if(baseOverride)return baseOverride-1;

 if (image == Images::Rune_Symbols) {
   static const uint8_t c[]={RUNE_SYMBOL_0,RUNE_SYMBOL_1,RUNE_SYMBOL_2,RUNE_SYMBOL_3,RUNE_SYMBOL_4,RUNE_SYMBOL_5,RUNE_SYMBOL_6,RUNE_SYMBOL_7};
   return c[frame%8];
 }
 if (image == Images::ItemShop_Potions) {
   static const uint8_t c[]={POTION_FIRE,POTION_HEALTH,POTION_SPEED}; return c[frame%3];
 }
 return e ? e->color : fallback;
}
bool spriteIsMask(const uint8_t *image) {
 const Entry *e=findStyle(image);return e && e->mask;
}

uint8_t colorArtId(const uint8_t *image) { const Entry *e=findStyle(image);return e?e->artId:255; }
